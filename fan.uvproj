# Keil uVision project fan.uvproj, settings and files
target fan (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: fan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source;..\fan
  group Source
    ./source/: main.c
    ./Source/: uart.c display.c eeprom.c timer.c ds18b20.c
